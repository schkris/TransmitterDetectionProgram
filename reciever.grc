options:
  parameters:
    generate_options: qt_gui
    id: reciever
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: usb_bottom_diff_1
  id: variable
  parameters:
    value: '"usb:1.2.5"'
  states: {}
- name: usb_top_sum_3
  id: variable
  parameters:
    value: '"usb:3.13.5"'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1.5e6
    low_cutoff_freq: 0.5e6
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1.5e6
    low_cutoff_freq: 0.5e6
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2399000000'
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: usb_bottom_diff_1
  states: {}
- name: iio_pluto_source_0_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2399000000'
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: usb_top_sum_3
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://*:5555
    timeout: '100'
    type: float
  states: {}
- name: zeromq_push_sink_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://*:5556
    timeout: '100'
    type: float
  states: {}
- name: zeromq_push_sink_0_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://*:5557
    timeout: '100'
    type: float
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [band_pass_filter_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_sub_xx_1, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_sub_xx_1, '1']
- [blocks_complex_to_mag_squared_0, '0', zeromq_push_sink_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', zeromq_push_sink_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_complex_to_arg_0_0, '0']
- [blocks_sub_xx_1, '0', zeromq_push_sink_0_0_0, '0']
- [iio_pluto_source_0, '0', band_pass_filter_0, '0']
- [iio_pluto_source_0, '0', blocks_add_xx_0, '1']
- [iio_pluto_source_0, '0', blocks_sub_xx_0, '1']
- [iio_pluto_source_0_0, '0', band_pass_filter_0_0, '0']
- [iio_pluto_source_0_0, '0', blocks_add_xx_0, '0']
- [iio_pluto_source_0_0, '0', blocks_sub_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
